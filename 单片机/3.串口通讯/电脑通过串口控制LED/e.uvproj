# Keil uVision project e.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: e +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c send_and_income.c head.h time.c light.c
